# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kpty-6.25.0.tar.xz"
SRC_URI[sha256sum] = "eb4deb424bdf20328dac0a12fdaab715dbf800e1cd08a4188cc2d3075543709f"

