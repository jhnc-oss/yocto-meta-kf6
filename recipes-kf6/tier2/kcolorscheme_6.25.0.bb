# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kcolorscheme-6.25.0.tar.xz"
SRC_URI[sha256sum] = "95a8a37817765f910c59b269a9958557505b99ff698fd6d220bcb166d5e302f5"

