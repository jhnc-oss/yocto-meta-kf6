# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kdoctools-6.25.0.tar.xz"
SRC_URI[sha256sum] = "2c5866257edda20f33c35f64a8bcab08de3dddb4e751bbbc2e09e941df979918"

