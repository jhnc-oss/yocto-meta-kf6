# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/knotifications-6.25.0.tar.xz"
SRC_URI[sha256sum] = "0884add69f26a455cb8b6327bf89dc7ad3a0e4397c43c202fcf7ff73204ec695"

