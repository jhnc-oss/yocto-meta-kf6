# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kcompletion-6.25.0.tar.xz"
SRC_URI[sha256sum] = "e4138d525eb9e27a9222d655e412c0de8b4bd7b34289d1c7ca5a808e20b53238"

