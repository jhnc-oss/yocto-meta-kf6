# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kcrash-6.25.0.tar.xz"
SRC_URI[sha256sum] = "b1b952c500787e760c0fca3ce20c6ed8cf488ed106e0e72bc604509df84d8fd7"

