# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kstatusnotifieritem-6.25.0.tar.xz"
SRC_URI[sha256sum] = "7a6397f08b15a7d50e407c193f1774b548994f6f9d12327dfbb674270adfc9af"

