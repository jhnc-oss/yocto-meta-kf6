# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kunitconversion-6.25.0.tar.xz"
SRC_URI[sha256sum] = "369ef042de797ea647994c524cc43915b514850026cfddb4b24bc78bdfc3dcc8"

