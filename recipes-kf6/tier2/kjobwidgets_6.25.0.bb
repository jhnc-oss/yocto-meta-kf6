# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kjobwidgets-6.25.0.tar.xz"
SRC_URI[sha256sum] = "756bdc0a1c89a8e732ea7299bd325c38b81604da76b4cf361ccfc8b40a6e781e"

