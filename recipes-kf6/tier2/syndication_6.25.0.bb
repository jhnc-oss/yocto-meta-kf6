# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/syndication-6.25.0.tar.xz"
SRC_URI[sha256sum] = "953f5935b1a0ba7c2c70cc213c0144d9c73855c802a1525be6c086543428f957"

