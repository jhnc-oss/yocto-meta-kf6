# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kfilemetadata-6.25.0.tar.xz"
SRC_URI[sha256sum] = "78b3516ab3038fec122f86c1370f4c7d8857ddea9e907263242affae1dd1f738"

