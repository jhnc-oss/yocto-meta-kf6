# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kimageformats-6.25.0.tar.xz"
SRC_URI[sha256sum] = "dfa0e9b16a288a8f94233afcbaffc87c1c5ddc037aca643943aab5a67685f26b"

