# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/frameworkintegration-6.25.0.tar.xz"
SRC_URI[sha256sum] = "eb8d55bd04cb023ea0480cf82c396d63b4a14ae7e5f60963a00a0d58f47a8022"

