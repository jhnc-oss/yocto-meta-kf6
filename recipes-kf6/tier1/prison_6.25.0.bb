# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/prison-6.25.0.tar.xz"
SRC_URI[sha256sum] = "9f4a8fa5732e45142c9ba2e35a38904d44193efc050e1ca20a414445c3a98b34"

