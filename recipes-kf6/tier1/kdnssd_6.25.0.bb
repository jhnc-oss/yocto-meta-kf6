# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kdnssd-6.25.0.tar.xz"
SRC_URI[sha256sum] = "865175616c5169d25f0783798e0a7918a418180c33828e461c1608e6121d3634"

