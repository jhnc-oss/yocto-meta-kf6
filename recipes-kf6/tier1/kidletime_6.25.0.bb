# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kidletime-6.25.0.tar.xz"
SRC_URI[sha256sum] = "64e83d46a15b444017c6341e479e229bbd6cbb8320ef1359773737cee89dd7ca"

