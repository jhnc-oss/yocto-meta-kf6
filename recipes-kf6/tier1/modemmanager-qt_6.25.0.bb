# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/modemmanager-qt-6.25.0.tar.xz"
SRC_URI[sha256sum] = "1f1c3ef493445a3f9215462dd86d25e2e4355ffbce9a70016288be04c537b91b"

