# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/networkmanager-qt-6.25.0.tar.xz"
SRC_URI[sha256sum] = "c3874938892c43ae8d486cd7b71e586f3ad368518cbf80034dcbf97516976756"

