# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/bluez-qt-6.25.0.tar.xz"
SRC_URI[sha256sum] = "e728c968d633cfd5921dd5cf5b424a33f17a7682d1c780437e15710aa3ff2101"

