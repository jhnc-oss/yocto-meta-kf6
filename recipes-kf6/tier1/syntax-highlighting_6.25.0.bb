# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/syntax-highlighting-6.25.0.tar.xz"
SRC_URI[sha256sum] = "8aeee428e82ac96aad01bbd423518705d214e0f3a5ac1fd64389565d08e5d501"

