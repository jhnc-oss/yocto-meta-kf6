# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kuserfeedback-6.25.0.tar.xz"
SRC_URI[sha256sum] = "4ce9fd672bed20ce646cd175522d207e0fe753fe42c5cf773c087927c0f30fe3"

