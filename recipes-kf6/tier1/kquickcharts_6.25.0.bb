# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kquickcharts-6.25.0.tar.xz"
SRC_URI[sha256sum] = "146598a1e107e8480631b3001fd39d264e81dd5af6a315dec71524465d099244"

