# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kguiaddons-6.25.0.tar.xz"
SRC_URI[sha256sum] = "38850963cb91978d08e781d81b147c7b66f78f4204ad820631e42ab1ef5ef76b"

