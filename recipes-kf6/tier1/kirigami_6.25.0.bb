# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kirigami-6.25.0.tar.xz"
SRC_URI[sha256sum] = "da7f3b733557b19975bb6b122e05d2f4d9214a70a81e2bb6e71c65761a3c6b43"

