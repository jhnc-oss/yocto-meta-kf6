# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/breeze-icons-6.25.0.tar.xz"
SRC_URI[sha256sum] = "2188492d83ead80cae83cbb0db80cac0b55388ea2e3e02d436354b6ca2559d0c"

