# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/sonnet-6.25.0.tar.xz"
SRC_URI[sha256sum] = "510521f1404914943b3141e0b111f2330bbeefdf40405f93c0cf7b84a8c1c589"

