# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kdbusaddons-6.25.0.tar.xz"
SRC_URI[sha256sum] = "b872463ff1874beeff86cf951e510488e959d595ca3d2839fb8e9639fbffb0e2"

