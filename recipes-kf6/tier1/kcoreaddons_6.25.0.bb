# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kcoreaddons-6.25.0.tar.xz"
SRC_URI[sha256sum] = "e7f0825576dc44af0c7194538e48114aa240f8fd3402f27047771f009e161a7e"

