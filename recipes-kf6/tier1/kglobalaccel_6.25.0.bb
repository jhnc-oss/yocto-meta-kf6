# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kglobalaccel-6.25.0.tar.xz"
SRC_URI[sha256sum] = "81f9842f13db8e2d4384c0f02650cd076441d2fba9540820901fffe1d2f4897f"

