# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kholidays-6.25.0.tar.xz"
SRC_URI[sha256sum] = "13c345422f802bd157aaea18b2ccb5270eb5e3de44915bcce70f1a4234e1497b"

