# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kitemmodels-6.25.0.tar.xz"
SRC_URI[sha256sum] = "ab78119a00b84eac65ffc986df30fbf9b1b8d00635e8fc626372e84580d158ca"

