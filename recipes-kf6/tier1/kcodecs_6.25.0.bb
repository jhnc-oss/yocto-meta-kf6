# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kcodecs-6.25.0.tar.xz"
SRC_URI[sha256sum] = "5051fe783803d94444a231c79635b96f1266594942b836f59ae8460497c788c5"

