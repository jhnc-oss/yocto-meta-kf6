# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/solid-6.25.0.tar.xz"
SRC_URI[sha256sum] = "8177fa8f139b855856e171426c5f2adb96d727e62e6ec536675da11aa157b33e"

