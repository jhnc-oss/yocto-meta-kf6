# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kconfig-6.25.0.tar.xz"
SRC_URI[sha256sum] = "8c675c9d35a866fbf1b564354a589019b429cca949f7ba3ba0adb9f2fa15959c"

