# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/threadweaver-6.25.0.tar.xz"
SRC_URI[sha256sum] = "f74ca31f5559f55870496df5372da09dfb409e197cc6e0f660979b98cd611444"

