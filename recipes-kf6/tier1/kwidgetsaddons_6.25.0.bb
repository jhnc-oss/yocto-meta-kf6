# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kwidgetsaddons-6.25.0.tar.xz"
SRC_URI[sha256sum] = "8a9f9cde4427ffec37a0501d337aadae3de39736674f571ff8a13d17d1e6c938"

