# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/karchive-6.25.0.tar.xz"
SRC_URI[sha256sum] = "123a268352ab63d548ba5e3c3e8fbf1d737025e4c5189821cf10e3328ab4de15"

