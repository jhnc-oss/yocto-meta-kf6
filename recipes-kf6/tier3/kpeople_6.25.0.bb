# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kpeople-6.25.0.tar.xz"
SRC_URI[sha256sum] = "8bece583572330449dfa735b589b1df276759dbbb3a1f3a4d134c5677e2bf558"

