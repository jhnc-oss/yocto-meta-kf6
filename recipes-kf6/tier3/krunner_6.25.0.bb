# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/krunner-6.25.0.tar.xz"
SRC_URI[sha256sum] = "a2cf0c9ae296868250b15b8446d657063a95c70d9d182b007814fb59efa50419"

