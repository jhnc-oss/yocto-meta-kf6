# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kparts-6.25.0.tar.xz"
SRC_URI[sha256sum] = "f0d6346e3127d1e44506733113be467d8b50cb82731d300a57990dd09baaedf1"

