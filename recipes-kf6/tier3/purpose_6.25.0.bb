# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/purpose-6.25.0.tar.xz"
SRC_URI[sha256sum] = "773abfa91f50ce10419373fdb4e7e0b2be009e739f8de2f3450d3ef169b6a23e"

