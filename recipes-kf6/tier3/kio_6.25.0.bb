# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kio-6.25.0.tar.xz"
SRC_URI[sha256sum] = "bf71b2227016df6566665cead6cb468726d7cc708059e812daee7ea54f405378"

