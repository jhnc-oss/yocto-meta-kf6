# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/ksvg-6.25.0.tar.xz"
SRC_URI[sha256sum] = "9c05166e289d39603696944edfbc3b50a1aadcd19e5b602002013c6149a44129"

