# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kdesu-6.25.0.tar.xz"
SRC_URI[sha256sum] = "09ad4bf5fe7abae40884f8b645b22948cd00f418c7d643a0b5d505a02ef6f634"

