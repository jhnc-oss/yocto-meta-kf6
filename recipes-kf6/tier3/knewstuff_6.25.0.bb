# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/knewstuff-6.25.0.tar.xz"
SRC_URI[sha256sum] = "8c31ef25a7d7389473d12245ae564ad888467b8ef910ac212e16e9334540cd08"

