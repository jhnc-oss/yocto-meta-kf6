# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kconfigwidgets-6.25.0.tar.xz"
SRC_URI[sha256sum] = "c45ee1f4b2ede987efc8deac48710d87d9d37bb8355f0d7e130d557dfb2029a2"

