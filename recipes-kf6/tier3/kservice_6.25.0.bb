# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kservice-6.25.0.tar.xz"
SRC_URI[sha256sum] = "04fa9f824e50c25b6ad7e29262c6566e0ce11edefb9fede317399a88501e9f74"

