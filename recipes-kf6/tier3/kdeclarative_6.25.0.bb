# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kdeclarative-6.25.0.tar.xz"
SRC_URI[sha256sum] = "7692ccdffd55826976e916927b59aeb2d24a77b16af967fb265e9fe0cde387fa"

