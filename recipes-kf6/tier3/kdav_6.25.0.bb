# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kdav-6.25.0.tar.xz"
SRC_URI[sha256sum] = "a16c4cc1b21cdf2739e1ba20b77a5212b9daabc7e395259771dd077f5200f14b"

