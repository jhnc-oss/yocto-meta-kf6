# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kxmlgui-6.25.0.tar.xz"
SRC_URI[sha256sum] = "02d97c24ec0bc102c299f3429056b45025e24d59ec31464317a3062cc1fc2021"

