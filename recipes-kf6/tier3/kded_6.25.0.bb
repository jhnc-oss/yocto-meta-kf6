# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/kded-6.25.0.tar.xz"
SRC_URI[sha256sum] = "030cc827c37b490a2181e120cd831b73c9a7683a87cf55d0d5b334059f78c590"

