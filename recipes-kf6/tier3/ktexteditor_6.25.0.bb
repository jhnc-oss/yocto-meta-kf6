# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/ktexteditor-6.25.0.tar.xz"
SRC_URI[sha256sum] = "77e815edcdf572397f5eb750d7232b366f6cc6274bb34246ab88f2f2179733b4"

