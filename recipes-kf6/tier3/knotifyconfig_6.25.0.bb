# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/6.25/knotifyconfig-6.25.0.tar.xz"
SRC_URI[sha256sum] = "8dc37406d8f13193216201752ece968cbd38da5a76780ad78575d11b47b440ea"

