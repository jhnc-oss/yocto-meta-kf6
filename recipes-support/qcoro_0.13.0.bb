# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "720ea7f6322bbba9f5d5aa3888a222397a1f72f1"
