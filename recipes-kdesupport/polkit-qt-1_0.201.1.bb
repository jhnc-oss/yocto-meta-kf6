# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "328a4c8615c7207e1297b776026657a77c6a71b6"
